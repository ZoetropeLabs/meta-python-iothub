inherit distutils-base

require python-iothub-common.inc

SRC_URI += "file://0001-use-boost-python.patch"
