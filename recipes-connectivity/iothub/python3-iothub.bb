inherit distutils3-base

require python-iothub-common.inc

SRC_URI += "file://0001-use-boost-python3.patch"
